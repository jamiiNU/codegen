# Keil uVision project NuCodeGenProj.uvprojx, settings and files
target NuCodeGenProj (6120000::V6.12::.\ARMCLANG)
  device: NUC1262SE4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NuCodeGenProj
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC1262\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_NUC1262.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
    ../../../../Library/Device/Nuvoton/NUC1262/Source/ARM/: startup_NUC1262.s
  group Library
    ../../../../Library/StdDriver/src/: adc.c bpwm.c clk.c crc.c fmc.c gpio.c i2c.c llsi.c pdma.c retarget.c spi.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group User
    ../: main.c clk_conf.c periph_conf.c pin_conf.c int_handler.c
  group USBD
    ../USBD/: usbd_class.c descriptors.c
