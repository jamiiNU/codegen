# IAR project NuCodeGenProj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC1262AE series Nuvoton NUC1262AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1262\Include; ..\..\..\..\Library\StdDriver\inc; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NuCodeGenProj.bin
  ILINK.IlinkOutputFile: NuCodeGenProj.out
  ILINK.IlinkIcfFile: nuc1262.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1262/Source/IAR/: startup_NUC1262.s
    ../../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c bpwm.c clk.c crc.c fmc.c gpio.c i2c.c llsi.c pdma.c retarget.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group USBD
    ../USBD/: descriptors.c usbd_class.c
  group User
    ../: clk_conf.c int_handler.c main.c periph_conf.c pin_conf.c
