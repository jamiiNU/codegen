# IAR project NuCodeGenProj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\Library\StdDriver\inc; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NuCodeGenProj.bin
  ILINK.IlinkOutputFile: NuCodeGenProj.out
  ILINK.IlinkIcfFile: m031.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library
    ../../../../Library/StdDriver/src/: acmp.c adc.c bpwm.c clk.c crc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c qspi.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group USBD
    ../USBD/: descriptors.c usbd_class.c
  group User
    ../: clk_conf.c int_handler.c main.c periph_conf.c pin_conf.c
