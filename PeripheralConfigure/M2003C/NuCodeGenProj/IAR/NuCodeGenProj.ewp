# IAR project NuCodeGenProj.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2003 series Nuvoton M2003 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2003\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NuCodeGenProj.bin
  ILINK.IlinkOutputFile: NuCodeGenProj.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/IAR/: startup_M2003.s
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c ecap.c fmc.c gpio.c i2c.c pwm.c retarget.c sys.c timer.c uart.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group User
    ../: clk_conf.c int_handler.c main.c periph_conf.c pin_conf.c
