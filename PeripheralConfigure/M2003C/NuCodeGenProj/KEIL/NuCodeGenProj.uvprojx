# Keil uVision project NuCodeGenProj.uvprojx, settings and files
target NuCodeGenProj (6120000::V6.12::.\ARMCLANG)
  device: M2003FC1AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.21
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NuCodeGenProj
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M2003\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M2003.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/ARM/: startup_M2003.s
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c ecap.c fmc.c gpio.c i2c.c pwm.c retarget.c sys.c timer.c uart.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group User
    ../: main.c clk_conf.c int_handler.c periph_conf.c pin_conf.c
software components: CMSIS:CORE 5.2.0
