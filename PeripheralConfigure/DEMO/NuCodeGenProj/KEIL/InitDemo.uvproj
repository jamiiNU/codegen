# Keil uVision project InitDemo.uvproj, settings and files
target UART (ARM-ADS)
  device: NUC472HI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=2
  c include: ..\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c periph_conf.c clk_conf.c pin_conf.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c clk.c retarget.c uart.c pdma.c acmp.c adc.c can.c cap.c crc.c crypto.c eadc.c ebi.c emac.c epwm.c fmc.c gpio.c i2c.c i2s.c ps2.c pwm.c rtc.c sc.c scuart.c sd.c spi.c timer.c usbd.c wdt.c wwdt.c
