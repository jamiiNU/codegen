# Keil uVision project NuCodeGenProj.uvprojx, settings and files
target NuCodeGenProj (6100001::V6.10.1::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NuCodeGenProj
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group Library
    ../../../../Library/StdDriver/src/: acmp.c bpwm.c clk.c crypto.c crc.c dac.c eadc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c qspi.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c timer_pwm.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c tk.c lcd.c
    ../../../../Library/SmartcardLib/: SmartCardLib.lib
    ../../../../Library/TKLib/: TKLib_Calibration.lib TKLib_FreeRun.lib
  group User
    ../: main.c clk_conf.c periph_conf.c pin_conf.c int_handler.c
  group USBD
    ../USBD/: usbd_class.c descriptors.c
